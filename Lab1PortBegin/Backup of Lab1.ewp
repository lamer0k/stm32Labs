# IAR project Backup of Lab1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4XX
  ICCARM.CCIncludePath2: ; $TOOLKIT_DIR$\inc\ST; $TOOLKIT_DIR$\CMSIS\Include; CMSIS; Application; AHardware\Gpio; AHardware\Leds
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ; $TOOLKIT_DIR$\inc\ST; $TOOLKIT_DIR$\CMSIS\Include; $PROJ_DIR$
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp startup_stm32F4xx_md.cpp
    ../../C/: main.ENU.projtempl
