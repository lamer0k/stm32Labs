# IAR project adc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; Common; AHardware; AHardware\GpioPort; AHardware\IrqController; CMSIS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos\FreeRtos
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware/GpioPort
    AHardware/GpioPort/: gpioport.hpp gpioports.hpp iport.hpp
  group AHardware/IrqController
    AHardware/IrqController/: irqcontroller.cpp
  group Application
    Application/: leds.hpp ledscontroller.cpp ledscontroller.hpp ledsdriver.hpp userbutton.hpp
  group Common
    Common/: singleton.hpp utils.hpp
